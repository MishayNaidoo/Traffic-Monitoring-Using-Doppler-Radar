<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MCP3914_STM32F051_Security.ewp</path>
  </project>
  <batchBuild />
</workspace>
